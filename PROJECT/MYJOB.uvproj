# Keil uVision project MYJOB.uvproj, settings and files
target MYJOB (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: MYJOB +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC;..\STC_LIB;..\APP;..\User
  group APP
    ../APP/: main.c task_manage.c test.c led.c app_usart.c
  group BSP
    ../BSP/: bsp.c globalvariable.c
  group STC_LIB
    ../STC_LIB/: GPIO.c USART.C
  group uCOSII521
    ../uCOSII251/: My_OS_CORE.C My_OS_CPU_C.C My_OS_TASK.C My_OS_TIME.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_CPU_A.ASM STARTUP.A51
